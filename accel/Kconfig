## accel/Kconfig
```kconfig
config TCG
    bool
    imply SEMIHOSTING

config KVM
    bool

config XEN
    bool
    select FSDEV_9P if VIRTFS
```
